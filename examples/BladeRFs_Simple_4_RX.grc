options:
  parameters:
    author: Vincenque
    catch_exceptions: 'False'
    generate_options: qt_gui
    id: py_BladeRF_Simple_4RX
    output_language: python
    title: BladeRF Simple 4RX
  states: {}

blocks:
- name: rx_bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: rx_frequency
  id: variable
  parameters:
    value: 1.57562e9
  states: {}
- name: rx_rf_gain
  id: variable_qtgui_range
  parameters:
    label: RX gain [-15;60]
    start: '-15'
    step: '1'
    stop: '60'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: vector_size
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    alias: master
    bias_tee0: 'False'
    bias_tee1: 'False'
    buffers: '512'
    buflen: '4096'
    bw: rx_bandwidth
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: xxxxxxxxMASTERxxxxxxxxx
    feature: default
    fpga_image: ''
    fpga_reload: 'False'
    freq: rx_frequency
    gain0: rx_rf_gain
    gain1: rx_rf_gain
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    maxoutbuf: '1024'
    metadata: 'False'
    nchan: '2'
    out_clk: 'True'
    ref_clk: 10e6
    sample_format: 16bit
    sample_rate: samp_rate
    sampling: internal
    show_pmic: 'False'
    smb: '0'
    tamer: internal
    trigger0: 'True'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: slave
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'False'
    verbosity: verbose
    xb200: none
  states: {}
- name: bladeRF_source_0_0
  id: bladeRF_source
  parameters:
    alias: slave
    bias_tee0: 'False'
    bias_tee1: 'False'
    buffers: '512'
    buflen: '4096'
    bw: rx_bandwidth
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: xxxxxxxxSLAVExxxxxxxxx
    feature: default
    fpga_image: ''
    fpga_reload: 'False'
    freq: rx_frequency
    gain0: rx_rf_gain
    gain1: rx_rf_gain
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    in_clk: EXTERNAL
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    maxoutbuf: '1024'
    metadata: 'False'
    nchan: '2'
    out_clk: 'False'
    ref_clk: 10e6
    sample_format: 16bit
    sample_rate: samp_rate
    sampling: internal
    show_pmic: 'False'
    smb: '0'
    tamer: internal
    trigger0: 'True'
    trigger1: 'False'
    trigger_role0: slave
    trigger_role1: slave
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'False'
    verbosity: verbose
    xb200: none
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Master RX1"'
    size: vector_size
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Master RX2"'
    size: vector_size
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Slave RX2"'
    size: vector_size
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Slave RX1"'
    size: vector_size
    srate: samp_rate
    type: complex
  states: {}

connections:
- [bladeRF_source_0, '0', qtgui_time_sink_x_0, '0']
- [bladeRF_source_0, '1', qtgui_time_sink_x_0_0, '0']
- [bladeRF_source_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [bladeRF_source_0_0, '1', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
